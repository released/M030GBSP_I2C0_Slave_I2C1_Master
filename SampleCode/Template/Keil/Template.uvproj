# Keil uVision project Template.uvproj, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M030GTD1AE Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M030G\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M030G.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M030G/Source/: system_M030G.c
    ../../../Library/Device/Nuvoton/M030G/Source/ARM/: startup_M030G.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c clk.c gpio.c sys.c timer.c adc.c dac.c fmc.c i2c.c crc.c
  group User
    ../: main.c i2c_master.c i2c_slave.c
